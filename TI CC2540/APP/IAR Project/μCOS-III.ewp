# IAR project μCOS-III.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: CC2540F256 CC2540F256
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: H:\TI ble环境搭建\工程\13 μCOS-iii移植2\uCOS-III\Source; H:\TI ble环境搭建\工程\13 μCOS-iii移植2\uCOS-III\Ports\51-CC2540\Generic\IAR; H:\TI ble环境搭建\工程\13 μCOS-iii移植2\uC-CPU; H:\TI ble环境搭建\工程\13 μCOS-iii移植2\uC-CPU\51-CC2540\IAR; H:\TI ble环境搭建\工程\13 μCOS-iii移植2\TI CC2540\BSP; H:\TI ble环境搭建\工程\13 μCOS-iii移植2\TI CC2540\APP; H:\TI ble环境搭建\工程\13 μCOS-iii移植2\uC-LIB
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2540F256.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_a.s51 bsp_inner.h bsp_interrupt.c bsp_led.c bsp_led.h bsp_uart.c bsp_uart.h
  group TI CC2540
    ../: app.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group uC-CPU
    ../../../uC-CPU/51-CC2540/IAR/: cpu.h cpu_a.asm cpu_c.c
    ../../../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC-LIB
    ../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC-LIB/Ports
    ../../../uC-LIB/Ports/51-CC2540/IAR/: lib_mem_a.asm
  group uCOS-III
    ../../../uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uCOS-III/Ports
    ../../../uCOS-III/Ports/51-CC2540/Generic/IAR/: os_cpu.h os_cpu_a.s51 os_cpu_c.c
