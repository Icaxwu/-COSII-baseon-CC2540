<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>2</parallelThreads>
        </cstatargs>
        <cstatsettings/>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>2</parallelThreads>
        </cstatargs>
        <cstatsettings/>
      </data>
    </settings>
  </configuration>
  <group>
    <name>BSP</name>
    <file>
      <name>$PROJ_DIR$\..\..\BSP\bsp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\BSP\bsp.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\BSP\bsp_inner.h</name>
    </file>
  </group>
  <group>
    <name>TI CC2540</name>
    <file>
      <name>$PROJ_DIR$\..\app.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\app_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\cpu_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\includes.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\os_app_hooks.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\os_app_hooks.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\os_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\os_cfg_app.h</name>
    </file>
  </group>
  <group>
    <name>uC-CPU</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\uC-CPU\51-CC2540\IAR\cpu.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uC-CPU\51-CC2540\IAR\cpu_a.asm</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uC-CPU\51-CC2540\IAR\cpu_c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uC-CPU\cpu_core.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uC-CPU\cpu_core.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uC-CPU\cpu_def.h</name>
    </file>
  </group>
  <group>
    <name>uC-LIB</name>
    <group>
      <name>Ports</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\uC-LIB\Ports\51-CC2540\IAR\lib_mem_a.asm</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\uC-LIB\lib_ascii.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uC-LIB\lib_ascii.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uC-LIB\lib_def.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uC-LIB\lib_math.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uC-LIB\lib_math.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uC-LIB\lib_mem.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uC-LIB\lib_mem.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uC-LIB\lib_str.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uC-LIB\lib_str.h</name>
    </file>
  </group>
  <group>
    <name>uCOS-III</name>
    <group>
      <name>Ports</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\uCOS-III\Ports\51-CC2540\Generic\IAR\os_cpu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\uCOS-III\Ports\51-CC2540\Generic\IAR\os_cpu_a.s51</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\uCOS-III\Ports\51-CC2540\Generic\IAR\os_cpu_c.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\uCOS-III\Source\os.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uCOS-III\Source\os_cfg_app.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uCOS-III\Source\os_core.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uCOS-III\Source\os_dbg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uCOS-III\Source\os_flag.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uCOS-III\Source\os_int.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uCOS-III\Source\os_mem.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uCOS-III\Source\os_msg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uCOS-III\Source\os_mutex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uCOS-III\Source\os_pend_multi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uCOS-III\Source\os_prio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uCOS-III\Source\os_q.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uCOS-III\Source\os_sem.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uCOS-III\Source\os_stat.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uCOS-III\Source\os_task.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uCOS-III\Source\os_tick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uCOS-III\Source\os_time.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uCOS-III\Source\os_tmr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uCOS-III\Source\os_type.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\uCOS-III\Source\os_var.c</name>
    </file>
  </group>
</project>


